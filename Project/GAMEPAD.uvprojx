# Keil uVision project GAMEPAD.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GAMEPAD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Firmware\CMSIS\ST\STM32F10x;..\Firmware\CMSIS;..\Firmware\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c
  group CMSIS
    ../Firmware/CMSIS/ST/STM32F10x/: system_stm32f10x.c
    ../Firmware/CMSIS/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Firmware
    ../Firmware/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
